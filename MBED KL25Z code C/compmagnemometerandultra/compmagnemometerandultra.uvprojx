# Keil uVision project compmagnemometerandultra.uvprojx, settings and files
target compmagnemometerandultra (ARM-ADS)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.pdsc
  output: compmagnemometerandultra
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_PORTOUT=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KL25Z -D__CORTEX_M0PLUS -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_SLEEP=1 --split_sections -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_M0P -DMBED_BUILD_TIMESTAMP=1487780236.64 -DTARGET_KLXX -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_CORTEX_M0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM0PLUS -Ospace -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS --cpu=Cortex-M0 -D__MBED_CMSIS_RTOS_CM
  c include: .; HCSR04; MMA8451Q; mbed/.; mbed/KL25Z; mbed/KL25Z/ARM;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-DARM_MATH_CM0PLUS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/KL25Z/ARM/MKL25Z4.sct
  group 
    ./: mbed_config.h HMC5883L.h HMC5883L.cpp main.cpp
  group KL25Z
    mbed/KL25Z/: MKL25Z4.h PeripheralNames.h PinNames.h PortNames.h cmsis.h cmsis_nvic.h core_cm0plus.h core_cmFunc.h core_cmInstr.h device.h gpio_object.h objects.h system_MKL25Z4.h
  group MMA8451Q
    MMA8451Q/: MMA8451Q.h MMA8451Q.cpp
  group HCSR04
    HCSR04/: HCSR04.h HCSR04.cpp
  group ARM
    mbed/KL25Z/ARM/: cmsis_nvic.o core_cm0.o startup_MKL25Z4.o sys.o system_MKL25Z4.o mbed.ar
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h LocalFileSystem.h PortIn.h PortInOut.h PortOut.h PwmOut.h SPI.h SPISlave.h Serial.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h analogin_api.h analogout_api.h can_api.h can_helper.h error.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h toolchain.h us_ticker_api.h wait_api.h
